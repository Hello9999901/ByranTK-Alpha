## firmware/Kconfig.defconfig
```kconfig
if SHIELD_BTK_ALPHA

config ZMK_KEYBOARD_NAME
    default "ByranTK-Alpha"

endif
```
